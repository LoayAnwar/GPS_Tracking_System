# Keil uVision project GPS_Tracking_system.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS_Tracking_system
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c sysTick.c UART1.c DIO_DRIVER.c DIO_DRIVER.h gps.h sysTick.h LCD_DRIVER.c LCD_DRIVER.h UART1.h startup.s
